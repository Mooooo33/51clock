# Keil uVision project 温度操作系统.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: RTX51_TEMP +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: buzz.c ds18b20.c system.c LCD1602.C
